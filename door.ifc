Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: door.ifc
Time: 2026-09-09T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Showroom R15
Made in: Showroom R15

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcDoor, Скрытая дверь ЗЕРКАЛО
In: Finished floor
Description: Coordination geometry; not a native wall-hosted family; OverallHeight: 2.0583 m; OverallWidth: 0.8966 m; PredefinedType: DOOR; OperationType: SINGLE_SWING_LEFT
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Model: skrytaya-dver-zerkalo; Finish: Зеркало обычное · с двух сторон; FinishOutside: Зеркало · Зеркало обычное; FinishInside: Как снаружи · Зеркало · Зеркало обычное; Opening: left-in; Source: https://invisible-doors.ru/public_files/recommendations.pdf; GeometryUse: interior visualisation and coordination; operator GLB frame section; simplified hardware; LeafWidthMm: 800; LeafHeightMm: 2000; LeafThicknessMm: 55; FrameProfile: АД-3П-5 Алком; FrameSectionMm: 59 x 44.3; FrameSourceSHA256: fe69c8d856e3883ac607518ee982475fb0650ab636a780c19748035ef0f4edc7; RecommendedOpeningWidthMm: 910; RecommendedOpeningHeightMm: 2070
